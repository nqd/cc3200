# IAR project ota.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\flc\; ..\..\include\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\simplelink\; ..\..\..\simplelink\Include\; ..\..\..\simplelink\Source\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: extlib_ota-cm3.srec
  ILINK.IlinkOutputFile: extlib_ota-cm3.out
  group (top)
    ../: CdnClient.c CdnClient.h LogClient.c LogClient.h OtaApp.c OtaApp.h OtaClient.c OtaClient.h OtaCommon.h OtaHttp.c OtaHttp.h
    ../../include/: ota_api.h
