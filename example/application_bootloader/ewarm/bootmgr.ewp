# IAR project bootmgr.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\oslib\; ..\..\..\third_party\FreeRTOS\source\; ..\..\..\third_party\FreeRTOS\source\include\; ..\..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4\; ..\..\..\simplelink_extlib\flc; ..\..\..\simplelink\; ..\..\..\simplelink\source; ..\..\..\simplelink\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootmgr.bin
  postbuild: bootgen.exe ..\relocator\ewarm\Release\Exe\relocator.bin $EXE_DIR$\bootmgr.bin  $EXE_DIR$\application_bootloader.bin
  ILINK.IlinkOutputFile: bootmgr.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: bootmgr.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\simplelink\ewarm\NON_OS_TINY\Exe\simplelink.a; ..\..\..\driverlib\ewarm\Release\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c startup_ewarm.c udma_if.c
